SUMMARY = "Headless CV180x/CV181x BSP kernel for Milk-V Duo and LicheeRV Nano"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

inherit kernel kernel-yocto

COMPATIBLE_MACHINE = "^(milkv-duo|milkv-duo-s|milkv-duo-256|licheerv-nano)$"
LINUX_VERSION = "5.10.4"
PV = "${LINUX_VERSION}+git"
KBRANCH = "cvitek-5.10.y"
SRCREV = "3e03379912ddc8d3f785aa00cf6bf4e7c334eda8"
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}/${MACHINE}:${THISDIR}/${BPN}:"
SRC_URI = " \
    git://github.com/scpcom/linux.git;protocol=https;branch=${KBRANCH} \
    file://0001-Add-Mailbox-Driver-for-cvitek.patch \
    file://0002-Add-Reset-for-C906L-ignore-clock-status-for-C906L-an.patch \
    file://0003-Add-Remoteproc-Driver-for-cvitek.patch \
    file://0004-headless-cv180x-remoteproc.patch \
    file://0005-use-standard-satp-csr-name.patch \
    file://defconfig \
    file://headless.cfg \
    file://${MACHINE}.dts \
    file://magnesium-headless.dtsi \
    file://magnesium-cv181x-headless.dtsi \
    file://multi.its \
    file://verify-headless.py \
"
DEPENDS += "u-boot-mkimage-native dtc-native"
KCONFIG_MODE = "alldefconfig"

python do_cvitek_prepare_dts() {
    import pathlib
    import shutil

    dest = pathlib.Path(d.getVar('S')) / 'arch/riscv/boot/dts/cvitek'
    unpack = pathlib.Path(d.getVar('UNPACKDIR'))
    for name in (d.getVar('MACHINE') + '.dts', 'magnesium-headless.dtsi',
                 'magnesium-cv181x-headless.dtsi'):
        shutil.copyfile(unpack / name, dest / name)

    dram = int(d.getVar('CVITEK_DRAM_SIZE'), 0)
    rtos = int(d.getVar('CVITEK_RTOS_SIZE'), 0)
    soc = d.getVar('CVITEK_SOC_FAMILY')
    values = {
        'MONITOR_ADDR': 0x80000000,
        'OPENSBI_SIZE': 0x80000,
        'KERNEL_MEMORY_ADDR': 0x80000000,
        'KERNEL_MEMORY_SIZE': dram - rtos,
        'FREERTOS_ADDR': 0x80000000 + dram - rtos,
        'FREERTOS_SIZE': rtos,
        'FREERTOS_RESERVED_ION_SIZE': 0,
        'ION_SIZE': 0,
        'FRAMEBUFFER_SIZE': 0,
    }
    header = '/* Generated by linux-cvitek: no multimedia reservations. */\n'
    header += ''.join('#define CVIMMAP_%s 0x%x\n' % item for item in values.items())
    header += '#define CVIMMAP_C906_CLK %s_CLK_C906_1\n' % soc.upper()
    header += '#define CVIMMAP_RPROC_COMPAT "cvitek,%s-c906_1"\n' % soc
    (dest / 'cvi_board_memmap.h').write_text(header)
    # This BSP's CV181x include uses a different name and otherwise picks up
    # the SDK's large multimedia memory map from dtc/include-prefixes.
    (dest / 'cv181x_board_memmap.h').write_text(header)

    # The BSP's wildcard uses ${src}, which fails for out-of-tree builds.
    # Build just this board, avoiding vendor DTSs requiring other memory maps.
    (dest / 'Makefile').write_text('dtb-y += %s.dtb\n' % d.getVar('MACHINE'))
}

addtask cvitek_prepare_dts after do_patch before do_configure

# Fail the build if Kconfig dependencies silently re-enable multimedia or
# drop the hardware driver while leaving the remoteproc framework enabled.
python do_cvitek_check_config() {
    import pathlib
    config = (pathlib.Path(d.getVar('B')) / '.config').read_text().splitlines()
    soc = d.getVar('CVITEK_SOC_FAMILY')
    if 'CONFIG_ARCH_%s=y' % soc.upper() not in config:
        bb.fatal('Incorrect CV18xx SoC kernel configuration for ' + d.getVar('MACHINE'))
    for symbol in ('REMOTEPROC', 'CVITEK_REMOTEPROC', 'CVITEK_MAILBOX',
                   'RPMSG_CHAR', 'RPMSG_VIRTIO', 'EXT4_FS'):
        if 'CONFIG_%s=y' % symbol not in config:
            bb.fatal('Required CV18xx kernel option missing: CONFIG_' + symbol)
    for symbol in ('MEDIA_SUPPORT', 'DRM', 'FB', 'ION', 'ION_CVITEK', 'CMA',
                   'DMA_CMA', 'CVI_MAILBOX', 'BLK_DEV_INITRD'):
        if any(line.startswith('CONFIG_%s=' % symbol) for line in config):
            bb.fatal('Headless CV18xx kernel option enabled: CONFIG_' + symbol)
}
addtask cvitek_check_config after do_configure before do_compile

do_compile:append() {
    install -d ${B}/magnesium-fit
    install -m 0644 ${B}/arch/riscv/boot/Image.gz ${B}/magnesium-fit/Image.gz
    install -m 0644 ${B}/arch/riscv/boot/dts/${KERNEL_DEVICETREE} ${B}/magnesium-fit/board.dtb
    install -m 0644 ${UNPACKDIR}/multi.its ${B}/magnesium-fit/multi.its
    cd ${B}/magnesium-fit
    mkimage -f multi.its uImage
}

do_install:append() {
    install -m 0644 ${B}/magnesium-fit/uImage ${D}/boot/uImage
}

python do_cvitek_check_dtb() {
    import pathlib
    import runpy
    verify = runpy.run_path(d.getVar('UNPACKDIR') + '/verify-headless.py')['verify']
    dtb = pathlib.Path(d.getVar('B')) / 'arch/riscv/boot/dts' / d.getVar('KERNEL_DEVICETREE')
    verify(dtb, int(d.getVar('CVITEK_DRAM_SIZE'), 0), int(d.getVar('CVITEK_RTOS_SIZE'), 0))
}
addtask cvitek_check_dtb after do_compile before do_install do_deploy

FILES:${KERNEL_PACKAGE_NAME}-image:append = " /boot/uImage"

do_deploy:append() {
    install -m 0644 ${B}/magnesium-fit/uImage ${DEPLOYDIR}/uImage-${MACHINE}
    ln -sf uImage-${MACHINE} ${DEPLOYDIR}/uImage
}
