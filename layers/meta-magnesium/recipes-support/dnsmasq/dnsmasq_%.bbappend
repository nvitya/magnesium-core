# Include DHCP/DNS support without starting it or changing existing network
# behaviour. AP-specific configuration enables this service when needed.
INHIBIT_UPDATERCD_BBCLASS = "1"
