FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-default-to-escape-prefix-mode.patch"
