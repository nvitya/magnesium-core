FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-symbol-why-skip-Kconfig-directories.patch"
