FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://magnesium-uboot.cfg"
